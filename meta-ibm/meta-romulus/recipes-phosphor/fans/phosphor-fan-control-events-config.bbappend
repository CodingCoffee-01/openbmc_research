FILESEXTRAPATHS_prepend_romulus := "${THISDIR}/${BPN}:"
FILESEXTRAPATHS_prepend_romulus2600 := "${THISDIR}/${BPN}:"
