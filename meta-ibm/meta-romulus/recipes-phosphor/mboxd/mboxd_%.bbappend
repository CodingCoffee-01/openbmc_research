MBOXD_FLASH_SIZE_romulus = "64M"
MBOXD_FLASH_SIZE_romulus2600 = "64M"
