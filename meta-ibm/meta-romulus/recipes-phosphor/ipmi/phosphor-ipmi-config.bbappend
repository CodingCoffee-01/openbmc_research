FILESEXTRAPATHS_prepend_romulus := "${THISDIR}/${PN}:"
FILESEXTRAPATHS_prepend_romulus2600 := "${THISDIR}/${PN}:"
