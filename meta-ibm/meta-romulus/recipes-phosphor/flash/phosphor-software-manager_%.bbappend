PACKAGECONFIG_append_romulus = " verify_signature"
PACKAGECONFIG_append_romulus2600 = " verify_signature"
