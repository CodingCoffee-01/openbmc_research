SYSTEMD_LINK_phosphor-msl-verify_append_romulus     = " ../phosphor-msl-verify.service:obmc-chassis-poweron@0.target.requires/phosphor-msl-verify.service"
SYSTEMD_LINK_phosphor-msl-verify_append_romulus2600 = " ../phosphor-msl-verify.service:obmc-chassis-poweron@0.target.requires/phosphor-msl-verify.service"
