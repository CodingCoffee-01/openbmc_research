RDEPENDS_${PN}-inventory_append_romulus = " openpower-occ-control id-button"
RDEPENDS_${PN}-extras_append_romulus = " phosphor-image-signing"
